# Keil uVision project HTTP_Server.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HTTP_Server
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20083800 size 0x800
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x7800
  group Source
    ./: main.c HTTP_Server.c HTTP_Server_CGI.c adc.c Lcd.c led.c rtc.c SNTP.c switch.c mktime.c lpc_types.h lpc17xx_iap.c RGB.c Uart.c Uart.h DAC.c Timer.c Timer.h
    Web/: Web.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif llblue.jpg logo.gif pabb.gif datetime.cgi td.cgx lcd.cgx
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: prog
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Network:CORE 7.12.0, Network:CORE 7.12.0, Network:Interface:ETH 7.12.0, Network:Service:SNTP Client 7.12.0, Network:Service:Web Server Compact 7.12.0, Network:Socket:TCP 7.12.0, Network:Socket:UDP 7.12.0, CMSIS Driver:Ethernet MAC 2.12.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
